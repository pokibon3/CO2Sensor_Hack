#include "digits.h"
#include "gfx.h"

typedef struct
{
  char c;
  const char *rows[32];   /* '#' = set; the row length is the glyph width */
} glyph_t;

static const glyph_t clock_glyphs[] = {
  {'0', {"..####..", ".######.", "###..###", "##....##", "##....##", "##....##", "##....##",
         "##....##", "##....##", "##....##", "###..###", ".######.", "..####.."}},
  {'1', {"...##...", "..###...", ".####...", "##.##...", "...##...", "...##...", "...##...",
         "...##...", "...##...", "...##...", "...##...", "...##...", ".######."}},
  {'2', {"..####..", ".######.", "###..###", "##....##", "......##", ".....###", "....###.",
         "...###..", "..###...", ".###....", "###.....", "########", "########"}},
  {'3', {"..####..", ".######.", "###..###", "......##", "......##", "...####.", "...####.",
         "......##", "......##", "##....##", "###..###", ".######.", "..####.."}},
  {'4', {".....##.", "....###.", "...####.", "..##.##.", ".##..##.", "##...##.", "##...##.",
         "########", "########", ".....##.", ".....##.", ".....##.", ".....##."}},
  {'5', {"########", "########", "##......", "##......", "##.###..", "#######.", "###..###",
         "......##", "......##", "##....##", "###..###", ".######.", "..####.."}},
  {'6', {"..####..", ".######.", "###..###", "##......", "##......", "##.###..", "#######.",
         "###..###", "##....##", "##....##", "###..###", ".######.", "..####.."}},
  {'7', {"########", "########", "......##", ".....###", ".....##.", "....###.", "....##..",
         "...###..", "...##...", "...##...", "..###...", "..##....", "..##...."}},
  {'8', {"..####..", ".######.", "###..###", "##....##", "###..###", ".######.", ".######.",
         "###..###", "##....##", "##....##", "###..###", ".######.", "..####.."}},
  {'9', {"..####..", ".######.", "###..###", "##....##", "##....##", "###..###", ".#######",
         "..###.##", "......##", "......##", "###..###", ".######.", "..####.."}},
  {'/', {"......##", "......##", ".....##.", ".....##.", "....##..", "....##..", "...##...",
         "...##...", "..##....", "..##....", ".##.....", ".##.....", "##......"}},
  {':', {"....", "....", "....", ".##.", ".##.", "....", "....",
         "....", "....", ".##.", ".##.", "....", "...."}},
  {'-', {"........", "........", "........", "........", "........", "........", ".######.",
         ".######.", "........", "........", "........", "........", "........"}},
  {' ', {"....", "....", "....", "....", "....", "....", "....",
         "....", "....", "....", "....", "....", "...."}},
};

static const glyph_t small_glyphs[] = {
  {'0', {".####.", "##..##", "##..##", "##..##", "##..##", "##..##", "##..##", "##..##", ".####."}},
  {'1', {"..##..", ".###..", "..##..", "..##..", "..##..", "..##..", "..##..", "..##..", ".####."}},
  {'2', {".####.", "##..##", "....##", "...##.", "..##..", ".##...", "##....", "##....", "######"}},
  {'3', {".####.", "##..##", "....##", "...##.", "..###.", "....##", "....##", "##..##", ".####."}},
  {'4', {"...##.", "..###.", ".####.", "##.##.", "##.##.", "######", "...##.", "...##.", "...##."}},
  {'5', {"######", "##....", "##....", "#####.", "....##", "....##", "....##", "##..##", ".####."}},
  {'6', {".####.", "##..##", "##....", "#####.", "##..##", "##..##", "##..##", "##..##", ".####."}},
  {'7', {"######", "....##", "...##.", "...##.", "..##..", "..##..", ".##...", ".##...", ".##..."}},
  {'8', {".####.", "##..##", "##..##", "##..##", ".####.", "##..##", "##..##", "##..##", ".####."}},
  {'9', {".####.", "##..##", "##..##", "##..##", ".#####", "....##", "....##", "##..##", ".####."}},
  {'%', {"##....#", "##...##", "....##.", "...##..", "..##...", ".##....", "##...##", "#....##", "......."}},
  {'-', {"......", "......", "......", "......", "######", "......", "......", "......", "......"}},
};

#include "digits_big.inc"

typedef struct
{
  const glyph_t *glyphs;
  int count, height, gap;
} font_t;

static const font_t fonts[] = {
  {clock_glyphs, sizeof(clock_glyphs) / sizeof(clock_glyphs[0]), 13, 2},
  {small_glyphs, sizeof(small_glyphs) / sizeof(small_glyphs[0]), 9, 1},
  {glyphs_32, sizeof(glyphs_32) / sizeof(glyphs_32[0]), 32, 3},
  {glyphs_16, sizeof(glyphs_16) / sizeof(glyphs_16[0]), 16, 1},
};

static const glyph_t *find(const font_t *f, char c)
{
  for(int i = 0; i < f->count; i++)
  {
    if(f->glyphs[i].c == c)
    {
      return &f->glyphs[i];
    }
  }
  return 0;
}

static int glyph_w(const glyph_t *g)
{
  int w = 0;
  while(g->rows[0][w] != '\0')
  {
    w++;
  }
  return w;
}

int digits_width(const char *s, int font)
{
  const font_t *f = &fonts[font];
  int w = 0;

  for(; *s != '\0'; s++)
  {
    const glyph_t *g = find(f, *s);
    w += (g != 0 ? glyph_w(g) : 4) + f->gap;
  }
  return w > 0 ? w - f->gap : 0;
}

void digits_draw(int x, int y, const char *s, int font, uint16_t color)
{
  const font_t *f = &fonts[font];

  for(; *s != '\0'; s++)
  {
    const glyph_t *g = find(f, *s);
    if(g == 0)
    {
      x += 4 + f->gap;
      continue;
    }
    for(int r = 0; r < f->height; r++)
    {
      /* one rectangle per horizontal run of set pixels */
      const char *row = g->rows[r];
      int c = 0;
      while(row[c] != '\0')
      {
        if(row[c] != '#')
        {
          c++;
          continue;
        }
        int start = c;
        while(row[c] == '#')
        {
          c++;
        }
        gfx_fill(x + start, y + r, c - start, 1, color);
      }
    }
    x += glyph_w(g) + f->gap;
  }
}
